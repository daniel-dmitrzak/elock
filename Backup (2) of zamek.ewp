# IAR project Backup (2) of zamek.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051x8 ST STM32F051x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX
  ICCARM.CCIncludePath2: Core; STM32F0xx_StdPeriph_Driver\inc; include; .
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: zamek.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group APP
    APPs/: loopback.c
    include/APPs/: loopback.h
    include/: Types.h
  group Driver/inc
    STM32F0xx_StdPeriph_Driver/inc/: stm32f0xx_exti.h stm32f0xx_flash.h stm32f0xx_gpio.h stm32f0xx_iwdg.h stm32f0xx_misc.h stm32f0xx_pwr.h stm32f0xx_rcc.h stm32f0xx_spi.h stm32f0xx_syscfg.h stm32f0xx_tim.h stm32f0xx_usart.h
  group Driver/src
    STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c
  group Include
    include/: util.h
  group Source
    ./: main.c util.c
  group System
    include/: config.h
    ./: startup_stm32f0xx.s stm32f0xx.h stm32f0xx_conf.h system_stm32f0xx.c
  group W5200/inc
    include/W5200/: md5.h socket.h spi2.h w5200.h
  group W5200/src
    W5200/: md5.c socket.c SPI2.c w5200.c
